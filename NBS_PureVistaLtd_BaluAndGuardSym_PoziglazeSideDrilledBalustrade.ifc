Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2018-02-14T12:17:59
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20151007_0715(x64) - Exporter 16.4.0.0 - Alternate UI 16.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013* Module: EDMstepFileFactory/EDMstandAlone* Creation date: Wed Feb 14 12:17:59 2018* Host: NCL-PI02* Database: C:\Users\connm\AppData\Local\Temp\{73D16AC5-D9B0-4A8D-8CE4-2EF5ED9F5974}\ifc* Database version: 5507* Database creation date: Wed Feb 14 12:17:58 2018* Schema: IFC2X3* Model: DataRepository.ifc* Model creation date: Wed Feb 14 12:17:58 2018* Header model: DataRepository.ifc_HeaderModel* Header model creation date: Wed Feb 14 12:17:58 2018* EDMuser: sdai-user* EDMgroup: sdai-group* License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 0, 549316; RefLongitude: 0, -7, -34, -450321; RefElevation: 0 mm

# IfcBuilding
COBie - Category: Project Information

# IfcBuildingStorey, Level 0
LongName: Level 0; Elevation: 0 mm
COBie - Category: Levels; Name: Level 0

# IfcRailing: Railing:NBS_PureVistaLtd_BalustradeAndGuardingSystem_PoziglazesideDrilledBalustrade_12mmglass, Railing:NBS_PureVistaLtd_BalustradeAndGuardingSystem_PoziglazesideDrilledBalustrade_12mmglass:294080
In: Level 0
PredefinedType: BALUSTRADE; Classification: Ss_25_15_60_05 (Uniclass2015); Material: Air, NBS_Concept, NBS_Glass_Single
BOS_General - Author: NBS; ProductInformation: https://pure-vista.com/posi-glaze/; ManufacturerName: Pure Vista Ltd; ManufacturerURL: https://pure-vista.com/; Revision: n/a; Version: 2; Uniclass2015Title: Balustrade and guarding systems; Uniclass2015Code: Ss_25_15_60_05; Uniclass2015Version: Systems v1.9; NBSDescription: Balustrade and guarding system; NBSReference: 25-25-10/110; NBSCertification: www.nationalbimlibrary.com/cert/rz0osyfr; BIMObjectName: NBS_PureVistaLtd_BalustradeAndGuardingSystem_PoziglazesideDrilledBalustrade_12mmGlass; OmniClassCode: 22-05 73 13; OmniClassTitle: Glazed Decorative Metal Railings; OmniClassVersion: Table 22 2012-05-16
NBS_Data - Infills: Toughened glass; RailsBaseRails: Aluminium; FixingToParentStructureOptions: Spit Guardia 12 x 105/20 or Wurth:‐ W‐Haz 12/10 Art no. 0905 212 002 or grade 10.9 hexagon headed M12 bolts for steel
Pset_RailingCommon - IsExternal: yes; Reference: n/a
IFC - IfcExportAs: IfcRailingType; IfcExportType: BALUSTRADE
COBie - AccessibilityPerformance: n/a; AssetType: Fixed; Category: Railings; CodePerformance: BS 6180-2011; Color: n/a; Constituents: n/a; Description: Glass balustrade systems; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: Anodized; Grade: AA20; Manufacturer: sales@purevista.co.uk; Material: Aluminium; ModelNumber: n/a; ModelReference: Poziglaze side Drilled Balustrade - 12 mm glass; Name: BalustradeAndGuardingSystem_PoziglazesideDrilledBalustrade_12mmGlass_PureVistaLtd; NominalHeight: 182 mm; NominalLength: 3000 mm; NominalWidth: 74.5 mm; ReplacementCost: n/a; Shape: n/a; Size: 3000 x 74.5 x 182 mm; SustainabilityPerformance: n/a; WarrantyDescription: 12 Month Warranty; WarrantyDurationLabor: n/a; WarrantyDurationParts: 1; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: sales@pure-vista.com; AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59

# IfcRailing: Railing:NBS_PureVistaLtd_BalustradeAndGuardingSystem_PoziglazesideDrilledBalustrade_15mmglass, Railing:NBS_PureVistaLtd_BalustradeAndGuardingSystem_PoziglazesideDrilledBalustrade_15mmglass:294488
In: Level 0
PredefinedType: BALUSTRADE; Classification: Ss_25_15_60_05 (Uniclass2015); Material: Air, NBS_Concept, NBS_Glass_Single
BOS_General - Author: NBS; ProductInformation: https://pure-vista.com/posi-glaze/; ManufacturerName: Pure Vista Ltd; ManufacturerURL: https://pure-vista.com/; Revision: n/a; Version: 2; Uniclass2015Title: Balustrade and guarding systems; Uniclass2015Code: Ss_25_15_60_05; Uniclass2015Version: Systems v1.9; NBSDescription: Balustrade and guarding system; NBSReference: 25-25-10/110; NBSCertification: www.nationalbimlibrary.com/cert/rz0osyfr; BIMObjectName: NBS_PureVistaLtd_BalustradeAndGuardingSystem_PoziglazesideDrilledBalustrade_15mmGlass; OmniClassCode: 22-05 73 13; OmniClassTitle: Glazed Decorative Metal Railings; OmniClassVersion: Table 22 2012-05-16
NBS_Data - Infills: Toughened glass; RailsBaseRails: Aluminium; FixingToParentStructureOptions: Spit Guardia 12 x 105/20 or Wurth:‐ W‐Haz 12/10 Art no. 0905 212 002 or grade 10.9 hexagon headed M12 bolts for steel
Pset_RailingCommon - IsExternal: yes; Reference: n/a
IFC - IfcExportAs: IfcRailingType; IfcExportType: BALUSTRADE
COBie - AccessibilityPerformance: n/a; AssetType: Fixed; Category: Railings; CodePerformance: BS 6180-2011; Color: n/a; Constituents: n/a; Description: Glass balustrade systems; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: Anodized; Grade: AA20; Manufacturer: sales@purevista.co.uk; Material: Aluminium; ModelNumber: n/a; ModelReference: Poziglaze side Drilled Balustrade - 15 mm glass; Name: BalustradeAndGuardingSystem_PoziglazesideDrilledBalustrade_15mmGlass_PureVistaLtd; NominalHeight: 182 mm; NominalLength: 3000 mm; NominalWidth: 74.5 mm; ReplacementCost: n/a; Shape: n/a; Size: 3000 x 74.5 x 182 mm; SustainabilityPerformance: n/a; WarrantyDescription: 12 Month Warranty; WarrantyDurationLabor: n/a; WarrantyDurationParts: 1; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: sales@pure-vista.com; AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59

# IfcRailing: Railing:NBS_PureVistaLtd_BalustradeAndGuardingSystem_PoziglazesideDrilledBalustrade_17-5mmglass, Railing:NBS_PureVistaLtd_BalustradeAndGuardingSystem_PoziglazesideDrilledBalustrade_17-5mmglass:294590
In: Level 0
PredefinedType: BALUSTRADE; Classification: Ss_25_15_60_05 (Uniclass2015); Material: Air, NBS_Concept, NBS_Glass_Single
BOS_General - Author: NBS; ProductInformation: https://pure-vista.com/posi-glaze/; ManufacturerName: Pure Vista Ltd; ManufacturerURL: https://pure-vista.com/; Revision: n/a; Version: 2; Uniclass2015Title: Balustrade and guarding systems; Uniclass2015Code: Ss_25_15_60_05; Uniclass2015Version: Systems v1.9; NBSDescription: Balustrade and guarding system; NBSReference: 25-25-10/110; NBSCertification: www.nationalbimlibrary.com/cert/rz0osyfr; BIMObjectName: NBS_PureVistaLtd_BalustradeAndGuardingSystem_PoziglazesideDrilledBalustrade_17.5mmGlass; OmniClassCode: 22-05 73 13; OmniClassTitle: Glazed Decorative Metal Railings; OmniClassVersion: Table 22 2012-05-16
NBS_Data - Infills: Toughened glass; RailsBaseRails: Aluminium; FixingToParentStructureOptions: Spit Guardia 12 x 105/20 or Wurth:‐ W‐Haz 12/10 Art no. 0905 212 002 or grade 10.9 hexagon headed M12 bolts for steel
Pset_RailingCommon - IsExternal: yes; Reference: n/a
IFC - IfcExportAs: IfcRailingType; IfcExportType: BALUSTRADE
COBie - AccessibilityPerformance: n/a; AssetType: Fixed; Category: Railings; CodePerformance: BS 6180-2011; Color: n/a; Constituents: n/a; Description: Glass balustrade systems; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: Anodized; Grade: AA20; Manufacturer: sales@purevista.co.uk; Material: Aluminium; ModelNumber: n/a; ModelReference: Poziglaze side Drilled Balustrade - 17.5 mm glass; Name: BalustradeAndGuardingSystem_PoziglazesideDrilledBalustrade_17.5mmGlass_PureVistaLtd; NominalHeight: 182 mm; NominalLength: 3000 mm; NominalWidth: 74.5 mm; ReplacementCost: n/a; Shape: n/a; Size: 3000 x 74.5 x 182 mm; SustainabilityPerformance: n/a; WarrantyDescription: 12 Month Warranty; WarrantyDurationLabor: n/a; WarrantyDurationParts: 1; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: sales@pure-vista.com; AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59

# IfcRailing: Railing:NBS_PureVistaLtd_BalustradeAndGuardingSystem_PoziglazesideDrilledBalustrade_19mmglass, Railing:NBS_PureVistaLtd_BalustradeAndGuardingSystem_PoziglazesideDrilledBalustrade_19mmglass:294700
In: Level 0
PredefinedType: BALUSTRADE; Classification: Ss_25_15_60_05 (Uniclass2015); Material: Air, NBS_Concept, NBS_Glass_Single
BOS_General - Author: NBS; ProductInformation: https://pure-vista.com/posi-glaze/; ManufacturerName: Pure Vista Ltd; ManufacturerURL: https://pure-vista.com/; Revision: n/a; Version: 2; Uniclass2015Title: Balustrade and guarding systems; Uniclass2015Code: Ss_25_15_60_05; Uniclass2015Version: Systems v1.9; NBSDescription: Balustrade and guarding system; NBSReference: 25-25-10/110; NBSCertification: www.nationalbimlibrary.com/cert/rz0osyfr; BIMObjectName: NBS_PureVistaLtd_BalustradeAndGuardingSystem_PoziglazesideDrilledBalustrade_19mmGlass; OmniClassCode: 22-05 73 13; OmniClassTitle: Glazed Decorative Metal Railings; OmniClassVersion: Table 22 2012-05-16
NBS_Data - Infills: Toughened glass; RailsBaseRails: Aluminium; FixingToParentStructureOptions: Spit Guardia 12 x 105/20 or Wurth:‐ W‐Haz 12/10 Art no. 0905 212 002 or grade 10.9 hexagon headed M12 bolts for steel
Pset_RailingCommon - IsExternal: yes; Reference: n/a
IFC - IfcExportAs: IfcRailingType; IfcExportType: BALUSTRADE
COBie - AccessibilityPerformance: n/a; AssetType: Fixed; Category: Railings; CodePerformance: BS 6180-2011; Color: n/a; Constituents: n/a; Description: Glass balustrade systems; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: Anodized; Grade: AA20; Manufacturer: sales@purevista.co.uk; Material: Aluminium; ModelNumber: n/a; ModelReference: Poziglaze side Drilled Balustrade - 19 mm glass; Name: BalustradeAndGuardingSystem_PoziglazesideDrilledBalustrade_19mmGlass_PureVistaLtd; NominalHeight: 182 mm; NominalLength: 3000 mm; NominalWidth: 74.5 mm; ReplacementCost: n/a; Shape: n/a; Size: 3000 x 74.5 x 182 mm; SustainabilityPerformance: n/a; WarrantyDescription: 12 Month Warranty; WarrantyDurationLabor: n/a; WarrantyDurationParts: 1; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: sales@pure-vista.com; AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59

# IfcRailing: Railing:NBS_PureVistaLtd_BalustradeAndGuardingSystem_PoziglazesideDrilledBalustrade_21-5mmSentryGlass, Railing:NBS_PureVistaLtd_BalustradeAndGuardingSystem_PoziglazesideDrilledBalustrade_21-5mmSentryGlass:294927
In: Level 0
PredefinedType: BALUSTRADE; Classification: Ss_25_15_60_05 (Uniclass2015); Material: Air, NBS_Concept, NBS_Glass_Single
BOS_General - Author: NBS; ProductInformation: https://pure-vista.com/posi-glaze/; ManufacturerName: Pure Vista Ltd; ManufacturerURL: https://pure-vista.com/; Revision: n/a; Version: 2; Uniclass2015Title: Balustrade and guarding systems; Uniclass2015Code: Ss_25_15_60_05; Uniclass2015Version: Systems v1.9; NBSDescription: Balustrade and guarding system; NBSReference: 25-25-10/110; NBSCertification: www.nationalbimlibrary.com/cert/rz0osyfr; BIMObjectName: NBS_PureVistaLtd_BalustradeAndGuardingSystem_PoziglazesideDrilledBalustrade_21.5mmSentryGlass; OmniClassCode: 22-05 73 13; OmniClassTitle: Glazed Decorative Metal Railings; OmniClassVersion: Table 22 2012-05-16
NBS_Data - Infills: Toughened glass; RailsBaseRails: Aluminium; FixingToParentStructureOptions: Spit Guardia 12 x 105/20 or Wurth:‐ W‐Haz 12/10 Art no. 0905 212 002 or grade 10.9 hexagon headed M12 bolts for steel
Pset_RailingCommon - IsExternal: yes; Reference: n/a
IFC - IfcExportAs: IfcRailingType; IfcExportType: BALUSTRADE
COBie - AccessibilityPerformance: n/a; AssetType: Fixed; Category: Railings; CodePerformance: BS 6180-2011; Color: n/a; Constituents: n/a; Description: Glass balustrade systems; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: Anodized; Grade: AA20; Manufacturer: sales@purevista.co.uk; Material: Aluminium; ModelNumber: n/a; ModelReference: Poziglaze side Drilled Balustrade - 21.5 mm Sentry glass; Name: BalustradeAndGuardingSystem_PoziglazesideDrilledBalustrade_21.5mmSentryGlass_PureVistaLtd; NominalHeight: 182 mm; NominalLength: 3000 mm; NominalWidth: 74.5 mm; ReplacementCost: n/a; Shape: n/a; Size: 3000 x 74.5 x 182 mm; SustainabilityPerformance: n/a; WarrantyDescription: 12 Month Warranty; WarrantyDurationLabor: n/a; WarrantyDurationParts: 1; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: sales@pure-vista.com; AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59

# IfcRailing: Railing:NBS_PureVistaLtd_BalustradeAndGuardingSystem_PoziglazesideDrilledBalustrade_21-5mmglass, Railing:NBS_PureVistaLtd_BalustradeAndGuardingSystem_PoziglazesideDrilledBalustrade_21-5mmglass:294801
In: Level 0
PredefinedType: BALUSTRADE; Classification: Ss_25_15_60_05 (Uniclass2015); Material: Air, NBS_Concept, NBS_Glass_Single
BOS_General - Author: NBS; ProductInformation: https://pure-vista.com/posi-glaze/; ManufacturerName: Pure Vista Ltd; ManufacturerURL: https://pure-vista.com/; Revision: n/a; Version: 2; Uniclass2015Title: Balustrade and guarding systems; Uniclass2015Code: Ss_25_15_60_05; Uniclass2015Version: Systems v1.9; NBSDescription: Balustrade and guarding system; NBSReference: 25-25-10/110; NBSCertification: www.nationalbimlibrary.com/cert/rz0osyfr; BIMObjectName: NBS_PureVistaLtd_BalustradeAndGuardingSystem_PoziglazesideDrilledBalustrade_21.5mmGlass; OmniClassCode: 22-05 73 13; OmniClassTitle: Glazed Decorative Metal Railings; OmniClassVersion: Table 22 2012-05-16
NBS_Data - Infills: Toughened glass; RailsBaseRails: Aluminium; FixingToParentStructureOptions: Spit Guardia 12 x 105/20 or Wurth:‐ W‐Haz 12/10 Art no. 0905 212 002 or grade 10.9 hexagon headed M12 bolts for steel
Pset_RailingCommon - IsExternal: yes; Reference: n/a
IFC - IfcExportAs: IfcRailingType; IfcExportType: BALUSTRADE
COBie - AccessibilityPerformance: n/a; AssetType: Fixed; Category: Railings; CodePerformance: BS 6180-2011; Color: n/a; Constituents: n/a; Description: Glass balustrade systems; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: Anodized; Grade: AA20; Manufacturer: sales@purevista.co.uk; Material: Aluminium; ModelNumber: n/a; ModelReference: Poziglaze side Drilled Balustrade - 21.5 mm glass; Name: BalustradeAndGuardingSystem_PoziglazesideDrilledBalustrade_21.5mmGlass_PureVistaLtd; NominalHeight: 182 mm; NominalLength: 3000 mm; NominalWidth: 74.5 mm; ReplacementCost: n/a; Shape: n/a; Size: 3000 x 74.5 x 182 mm; SustainabilityPerformance: n/a; WarrantyDescription: 12 Month Warranty; WarrantyDurationLabor: n/a; WarrantyDurationParts: 1; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: sales@pure-vista.com; AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
